# Keil uVision project BH-F429.uvprojx, settings and files
target SDRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SDRAM +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER
  c include: ..\..\DSP_LIB;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\uCOS_III\uC-CPU;..\..\uCOS_III\uC-LIB;..\..\uCOS_III\uCOS-III\Ports;..\..\uCOS_III\uCOS-III\Source;..\..\emWin\Config;..\..\emWin\inc;..\..\emWin\Lib;..\..\emWin\OS;..\..\FATFS;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\BSP\font;..\..\User\BSP\lcd;..\..\User\BSP\led;..\..\User\BSP\sdram;..\..\User\BSP\usart;..\..\User\BSP\sdio;..\..\User\User_APP;..\..\User\BSP\DHT22;..\..\User\User_APP\delay;..\..\User\BSP\adc;..\..\User\BSP\rng;..\..\User\BSP\i2c;..\..\User\BSP\mpu6050;..\..\User\BSP\TOUCH;..\..\emWin;..\..\User\BSP\RTC;..\..\User\BSP\mpu6050\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group DISP_Lib
    ../../DSP_LIB/: arm_cortexM4lf_math.lib
  group USER
    ../../User/: stm32f4xx_it.c
  group BSP
    ../../User/BSP/: bsp.c bsp.h
    ../../User/BSP/font/: fonts.c
    ../../User/BSP/lcd/: bsp_lcd.c
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/sdram/: bsp_sdram.c
    ../../User/BSP/usart/: bsp_debug_usart.c bsp_usart3.c bsp_usart6.c
    ../../User/BSP/sdio/: bsp_sdio_sd.c
    ../../User/BSP/DHT22/: bsp_DHT22.c
    ../../User/BSP/adc/: bsp_adc.c
    ../../User/BSP/rng/: bsp_rng.c
    ../../User/BSP/i2c/: bsp_i2c_gpio.c
    ../../User/BSP/mpu6050/: mpu6050.c
    ../../User/BSP/TOUCH/: touch.c ctiic.c gt9147.c
    ../../User/BSP/RTC/: bsp_rtc.c
    ../../User/BSP/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group APP
    ../../User/APP/: app.c app.h app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
    ../../User/User_APP/: show_BMP.c show_GIF.c show_jpg.c print.c
  group uCOSIII-CPU
    ../../uCOS_III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h cpu.h cpu_a.asm cpu_c.c
  group uCOSIII-LIB
    ../../uCOS_III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group uCOSIII-Soure
    ../../uCOS_III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uCOSIII-Port
    ../../uCOS_III/uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group FATFS
    ../../FATFS/: diskio.c ff.c
    ../../FATFS/option/: cc936.c
  group EMWIN
    ../../emWin/OS/: GUI_X_uCOS.c
    ../../emWin/Config/: GUIConf.c LCDConf_Lin_Template.c GUI_X_Touch_Analog.c
    ../../emWin/Lib/: STemWin540_CM4_OS_Keil.lib
    ../../emWin/: WindowDLG.c beijing.c speaker.c setting.c planner.c music.c folder.c camera.c armclock.c about.c
